# Autodesk Inventor assembly: 21.1055 HINGE 32S
## iProperties
Created: 2011-06
Part Number: 21.1055 HINGE 32S
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
